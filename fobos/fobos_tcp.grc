options:
  parameters:
    generate_options: no_gui
    id: fobos_tcp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: RigExpert_fobos_sdr_0
  id: RigExpert_fobos_sdr
  parameters:
    clock_source: '0'
    direct_sampling: '0'
    frequency: center_freq_arg
    index: '0'
    lna_gain: lna_arg
    maxoutbuf: '2048'
    samplerate: sample_rate_arg
    vga_gain: vga_arg
  states: {}
- name: center_freq_arg
  id: parameter
  parameters:
    label: center_freq
    short_id: f
    type: eng_float
    value: 100e6
  states: {}
- name: ip_arg
  id: parameter
  parameters:
    label: ip
    short_id: i
    type: str
    value: localhost
  states: {}
- name: lna_arg
  id: parameter
  parameters:
    label: lna
    short_id: l
    type: intx
    value: '0'
  states: {}
- name: port_arg
  id: parameter
  parameters:
    label: port
    short_id: p
    type: intx
    value: '2000'
  states: {}
- name: sample_rate_arg
  id: parameter
  parameters:
    label: sample_rate
    short_id: s
    type: eng_float
    value: 25e6
  states: {}
- name: vga_arg
  id: parameter
  parameters:
    label: vga
    short_id: v
    type: intx
    value: '0'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: f"tcp://{ip_arg}:{port_arg}"
    timeout: '100'
    type: complex
  states: {}

connections:
- [RigExpert_fobos_sdr_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
