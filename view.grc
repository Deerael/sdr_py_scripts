options:
  parameters:
    generate_options: qt_gui
    id: view
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: parameter
  parameters:
    label: center freq
    short_id: f
    type: intx
    value: int(100e6)
  states: {}
- name: ip_arg
  id: parameter
  parameters:
    label: ip
    short_id: i
    type: str
    value: localhost
  states: {}
- name: port_arg
  id: parameter
  parameters:
    label: port
    short_id: p
    type: intx
    value: int(2e3)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    maxoutbuf: '2048'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: intx
    value: int(10e6)
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: f"tcp://{ip_arg}:{port_arg}"
    maxoutbuf: '2048'
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_sub_source_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
