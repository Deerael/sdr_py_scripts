options:
  parameters:
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: soapy_tcp
    output_language: python
    title: soapy_tcp
  states: {}

blocks:
- name: centre_freq
  id: parameter
  parameters:
    label: centre_freq
    short_id: f
    type: eng_float
    value: 100e6
  states: {}
- name: cmd_port
  id: parameter
  parameters:
    label: cmd port
    type: intx
    value: '2001'
  states: {}
- name: data_port
  id: parameter
  parameters:
    label: data port
    type: intx
    value: '2000'
  states: {}
- name: device
  id: parameter
  parameters:
    label: device driver
    type: str
    value: fobos
  states: {}
- name: ip
  id: parameter
  parameters:
    label: ip
    short_id: i
    type: str
    value: localhost
  states: {}
- name: lna
  id: parameter
  parameters:
    label: lna
    short_id: l
    type: intx
    value: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    short_id: s
    type: eng_float
    value: 25e6
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    bandwidth0: '1'
    center_freq0: centre_freq
    dc_removal0: 'False'
    driver: device
    gain0: lna + vga
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: vga
  id: parameter
  parameters:
    label: vga
    short_id: v
    type: intx
    value: '1'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: f"tcp://{ip}:{data_port}"
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: f"tcp://{ip}:{cmd_port}"
    timeout: '100'
  states: {}

connections:
- [soapy_custom_source_0, '0', zeromq_pub_sink_0, '0']
- [zeromq_sub_msg_source_0, out, soapy_custom_source_0, cmd]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1096-gc61887f7
