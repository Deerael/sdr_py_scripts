options:
  parameters:
    generate_options: qt_gui
    id: wbfm_rx_mono_ll
    output_language: python
    thread_safe_setters: '1'
    title: Not titled yet
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: int(samp_rate / decim / decim_2 / audio_samp_rate)
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(50e3)
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate / 1e6)
  states: {}
- name: decim_2
  id: variable
  parameters:
    value: int((samp_rate / decim) / 0.25e6)
  states: {}
- name: wbfm_deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate / decim / decim_2
    tau: '50e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 0.25e6/(2*math.pi* wbfm_deviation)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: centre_freq - signal_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: centre_freq
  id: parameter
  parameters:
    label: centre_freq
    short_id: c
    type: eng_float
    value: int(100e6)
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: audio_decim
    gain: '1'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '5'
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: ip_arg
  id: parameter
  parameters:
    label: ip
    short_id: i
    type: str
    value: localhost
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: decim_2
    gain: '1'
    samp_rate: int(samp_rate / decim)
    type: fir_filter_ccf
    width: 15e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: audio_decim
    gain: '1'
    samp_rate: samp_rate / decim / decim_2
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: port_arg
  id: parameter
  parameters:
    label: port
    short_id: p
    type: intx
    value: int(2e3)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: centre_freq
    fftsize: '1024'
    grid: 'True'
    name: '"native"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: centre_freq
    fftsize: '1024'
    grid: 'True'
    name: '"agc"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    fc: centre_freq
    fftsize: '1024'
    grid: 'True'
    name: '"xlating fir"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 0.25e6
    fc: centre_freq
    fftsize: '1024'
    grid: 'True'
    name: '"lowpas"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    name: '"audio fft"'
    type: float
    ymax: '100'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: 0.25e6
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    name: '"deemph"'
    type: float
    wintype: window.WIN_HAMMING
    ymax: '150'
    ymin: '0'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: '1'
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    short_id: s
    type: eng_float
    value: int(10e6)
  states: {}
- name: signal_freq
  id: parameter
  parameters:
    label: frequency of wfm station
    short_id: f
    type: eng_float
    value: int(103.5e6)
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: f"tcp://{ip_arg}:{port_arg}"
    maxoutbuf: '2048'
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_fm_deemph_0, '0', high_pass_filter_0, '0']
- [analog_fm_deemph_0, '0', qtgui_freq_sink_x_3, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [zeromq_sub_source_0, '0', blocks_multiply_xx_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
