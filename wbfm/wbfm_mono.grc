options:
  parameters:
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: wbfm_mono
    output_language: python
    thread_safe_setters: '1'
    title: 'tcp client wvfm demodulation in mono audio '
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate / 1e6)
  states: {}
- name: decim_2
  id: variable
  parameters:
    value: int((samp_rate / decim) / 0.25e6)
  states: {}
- name: wbfm_deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_samp_rate
    tau: '50e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 0.25e6/(2*math.pi* wbfm_deviation)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: centre_freq - signal_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    mode: vector
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: centre_freq
  id: parameter
  parameters:
    label: centre_freq
    short_id: c
    type: eng_float
    value: int(100e6)
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: ip_arg
  id: parameter
  parameters:
    label: ip
    short_id: i
    type: str
    value: localhost
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: decim_2
    gain: '1'
    samp_rate: int(samp_rate / decim)
    type: fir_filter_ccf
    width: 15e3
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 14e3
    decim: '1'
    gain: '1'
    samp_rate: int(samp_rate / decim / decim_2)
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: port_arg
  id: parameter
  parameters:
    label: port
    short_id: p
    type: intx
    value: int(2e3)
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    fbw: '0.3'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int((samp_rate / decim / decim_2 / 1e3) /2)
    fbw: '0.4'
    interp: int((audio_samp_rate / 1e3)/2)
    taps: ''
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    short_id: s
    type: eng_float
    value: int(10e6)
  states: {}
- name: signal_freq
  id: parameter
  parameters:
    label: frequency of wfm station
    short_id: f
    type: eng_float
    value: int(99.6e6)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demod
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: f"tcp://{ip_arg}:{port_arg}"
    maxoutbuf: '2048'
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', analog_fm_deemph_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', dc_blocker_xx_0, '0']
- [virtual_source_0, '0', low_pass_filter_1, '0']
- [zeromq_sub_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1096-gc61887f7
