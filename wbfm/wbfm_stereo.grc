options:
  parameters:
    generate_options: no_gui
    id: wbfm_stereo
    output_language: python
    thread_safe_setters: '1'
    title: tcp source wbfm with stereo audio
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(samp_rate / 1e6)
  states: {}
- name: decim_2
  id: variable
  parameters:
    value: int((samp_rate / decim) / 0.25e6)
  states: {}
- name: wbfm_deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_samp_rate
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_samp_rate
    tau: '50e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: '1e-6'
    min_freq: '1e-5'
    w: math.pi / 200
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 0.25e6/(2*math.pi* wbfm_deviation)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: centre_freq - signal_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 19.2e3
    low_cutoff_freq: 18.8e3
    samp_rate: samp_rate / decim / decim_2
    type: fir_filter_fcc
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 53e3
    low_cutoff_freq: 23e3
    samp_rate: samp_rate / decim / decim_2
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 38.1e3
    low_cutoff_freq: 37.9e3
    samp_rate: samp_rate / decim / decim_2
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: centre_freq
  id: parameter
  parameters:
    label: centre_freq
    short_id: c
    type: eng_float
    value: int(100e6)
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: ip_arg
  id: parameter
  parameters:
    label: ip
    short_id: i
    type: str
    value: localhost
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: decim_2
    gain: '1'
    samp_rate: int(samp_rate / decim)
    type: fir_filter_ccf
    width: 15e3
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim / decim_2
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim / decim_2
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 13e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim / decim_2
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_3
  id: low_pass_filter
  parameters:
    cutoff_freq: 13e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decim / decim_2
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: port_arg
  id: parameter
  parameters:
    label: port
    short_id: p
    type: intx
    value: int(2e3)
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decim
    fbw: '0.4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int((samp_rate / decim / decim_2 / 1e3) / 2)
    fbw: '0.4'
    interp: int((audio_samp_rate / 1e3) / 2)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: int((samp_rate / decim / decim_2 / 1e3) / 2)
    fbw: '0.4'
    interp: int((audio_samp_rate / 1e3) / 2)
    taps: ''
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sample rate
    short_id: s
    type: eng_float
    value: int(10e6)
  states: {}
- name: signal_freq
  id: parameter
  parameters:
    label: frequency of wfm station
    short_id: f
    type: eng_float
    value: int(102.5e6)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demoded
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pilot_pll
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: stereo_band
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demoded
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: demoded
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: demoded
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: pilot_pll
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: stereo_band
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_source_6_0
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: f"tcp://{ip_arg}:{port_arg}"
    maxoutbuf: '2048'
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_1, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_1, '1']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', analog_pll_refout_cc_0, '0']
- [band_pass_filter_0_0, '0', virtual_sink_2, '0']
- [band_pass_filter_1, '0', virtual_sink_1, '0']
- [blocks_add_xx_0, '0', low_pass_filter_1, '0']
- [blocks_complex_to_imag_0, '0', band_pass_filter_1, '0']
- [blocks_multiply_const_vxx_0, '0', dc_blocker_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', dc_blocker_xx_1, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_1_0, '0', low_pass_filter_3, '0']
- [blocks_sub_xx_0, '0', low_pass_filter_1_0, '0']
- [dc_blocker_xx_0, '0', audio_sink_0, '1']
- [dc_blocker_xx_1, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_1_0, '0', rational_resampler_xxx_1_0, '0']
- [low_pass_filter_2, '0', virtual_sink_3, '0']
- [low_pass_filter_3, '0', virtual_sink_4, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', analog_fm_deemph_0_0, '0']
- [rational_resampler_xxx_1_0, '0', analog_fm_deemph_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_0, '0']
- [virtual_source_1, '0', low_pass_filter_2, '0']
- [virtual_source_2, '0', band_pass_filter_0, '0']
- [virtual_source_3, '0', blocks_multiply_xx_1_0, '0']
- [virtual_source_4, '0', blocks_multiply_xx_1_0, '1']
- [virtual_source_5, '0', blocks_sub_xx_0, '0']
- [virtual_source_5_0, '0', blocks_add_xx_0, '0']
- [virtual_source_6, '0', blocks_sub_xx_0, '1']
- [virtual_source_6_0, '0', blocks_add_xx_0, '1']
- [zeromq_sub_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
